<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\unit_3_5.ewp</path>
  </project>
  <batchBuild />
</workspace>
